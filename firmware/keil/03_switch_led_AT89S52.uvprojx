# Keil uVision project 03_switch_led_AT89S52.uvprojx, settings and files
target AT89S52 (0x1000000)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODC2
  output: 03_switch_led +hex
  c include: ..\inc
