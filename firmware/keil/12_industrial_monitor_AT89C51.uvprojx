# Keil uVision project 12_industrial_monitor_AT89C51.uvprojx, settings and files
target AT89C51 (0x1000000)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(11059200) MODC2
  output: 12_industrial_monitor +hex
  c define: CHIP_AT89C51
  c include: ..\inc
