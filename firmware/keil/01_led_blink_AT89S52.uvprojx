# Keil uVision project 01_led_blink_AT89S52.uvprojx, settings and files
target AT89S52 (0x1000000)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODC2
  output: 01_led_blink +hex
  c include: ..\inc
